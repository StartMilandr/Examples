# Keil uVision project Hello.uvprojx, settings and files
target RAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: Hello_RAM
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\env
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  group Source Group 1
    ./: Hello.c
    ./env/: startup.s
target FLASH (ARM-ADS)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: Hello_Flash
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\env
  memory RVCT4: ROM 0x1000000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x10000
software components: Compiler:I/O:STDOUT 1.2.0
