# Keil uVision project EEPROM_Sect_VE93.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR1986BE93 Milandr
  pack: Keil.MDR1986BExx.1.51
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: eeprom4_93
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\EEPROM_VE93;..\src;..\scr_brd
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group eedprom4_93
    ../src/: EEPROM_Test.c main.c
    ../scr_brd/: brdBtn.c brdLed.c
software components: Device:Startup 1.5, Drivers:EEMPROM 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5
