# Keil uVision project CORDIC.uvprojx, settings and files
target RAM (6100001::V6.10.1::.\ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: CORDIC +hex
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\env
  memory RVCT4: ROM 0x2000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  group Source Group 1
    ./: startup.s CORDIC.c
target FLASH (6100001::V6.10.1::.\ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: CORDIC +hex
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\env
  memory RVCT4: ROM 0x1000000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x10000
software components: CMSIS:CORE 5.1.2, Compiler:I/O:STDOUT 1.2.0
