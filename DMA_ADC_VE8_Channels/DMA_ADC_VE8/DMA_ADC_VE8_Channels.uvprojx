# Keil uVision project DMA_ADC_VE8_Channels.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR32F8 Milandr
  pack: Keil.MDR32F8.0.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x20006000,0x2000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: DMA_ADC_VE8
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\DMA_ADC_VE8;..\..\DMA_ADC;..\src_brd
  memory RVCT4: ROM 0x20006000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group user
    ../: main.c
    ../src_brd/: brdClock_VE8.c brdUtils.c brdLed_VE8.c brdADC_VE8.c brdDMA.c
software components: Board Support:Board Setup 0.0.1, Device:Startup 0.0.1, Drivers:ADC 0.0.1, Drivers:CLKCTRL 0.0.1, Drivers:DMA 0.0.1, Drivers:PORT 0.0.1
