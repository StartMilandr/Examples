# Keil uVision project ExtBus32_1636RR1_VE1.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.1.51
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: ExtBus32_1636RR1_VE1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\VE1;..\src;..\src_brd
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group user
    ../src/: main.c
    ../src_brd/: brdBtn.c brdClock.c brdExtBus.c brdFlash_ExtBus.c brdLed.c
software components: Device:Startup 1.5, Drivers:BKP 1.5, Drivers:EBC 1.5, Drivers:EEMPROM 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5
