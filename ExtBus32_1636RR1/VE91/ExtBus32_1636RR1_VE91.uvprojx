# Keil uVision project ExtBus32_1636RR1_VE91.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.51
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ExtBus32_1636RR1_VE91
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\src;..\src_brd;..\VE91
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c
    ../src_brd/: brdBtn.c brdClock.c brdExtBus.c brdFlash_ExtBus.c brdLed.c brdUtils.c
software components: Device:Startup 1.5, Drivers:EBC 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5
