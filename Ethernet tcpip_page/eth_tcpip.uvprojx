# Keil uVision project eth_tcpip.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE3T Milandr
  pack: Keil.MDR1986BExx.1.5
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: eth_tcpip
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group Source Group 1
    ./src/: Main.c MDR1986VE3_IT.c tcpip.c
software components: Device:Startup 1.5, Drivers:DMA 1.5, Drivers:EEMPROM 1.5, Drivers:Ethernet 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5, Drivers:TIMER 1.5, Drivers:UART 1.5
